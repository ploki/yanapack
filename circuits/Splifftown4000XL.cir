*
* SPLIFFTOWN 4000 XL
*

.include circuits/driver.cir
.include circuits/closed_cab.cir

Eg    1 0    2.83

Rbsc  1 2    4.9
Lbsc  1 2    1.4m 0.36
L1    2 3    0.8m 0.22
C1    3 0   22u
R1    3 4    6
C3    4 0   22u

X26W/8534G00 3 0 5 6 driver param: { .96m TO Le 5.7 TO Re 10.1 TO Bl \
		  	             0.80 TO Rms 0.95m TO Cms 50.5m TO Mms \
			             350cm² TO Sd }
ZrW1  5 aGND  350cm² ai
ZrW2  6 7     350cm² ai
*Box  7 aGND   37L
XBox  7 aGND closed_cab param: { 37L TO Vb 7 TO Qb 50 TO Ql \
                                 .96m TO Le 5.7 TO Re 10.1 TO Bl \
		  	         0.80 TO Rms 0.95m TO Cms 50.5m TO Mms \
			         350cm² TO Sd }

RbT   1 8    3.25
C4    8 9    5.6u
L2    9 0    0.35m 0.14
R3    9 0   18

XD2905/9700 9 0 10 11 driver param: { .01m TO Le 4.7 TO Re 3.5 TO Bl \
		                      0.41 TO Rms 0.23m TO Cms 0.45m TO Mms \
			              8.5cm² TO Sd }
ZrT1  10 aGND  8.5cm² ai
ZrT2  11 aGND  8.cm² ai

* set logscale x
* set mxtics
* set mytics
* set style line 12 lc rgb '#ddccdd' lt 1 lw 1.5
* set style line 13 lc rgb '#ddccdd' lt 1 lw 0.5
* set grid xtics mxtics ytics mytics back ls 12, ls 13
* plot [16:40000] [40:100] 'plop.txt' using 1:2 title 'sum' with lines, 'plop.txt' using 1:3 title 'woofer' with lines, 'plop.txt' using 1:4 title 'tweeter' with lines

!general properties
. 350cm²   TO woofer_Sd    IZrW1 TO woofer_volume_velocity
.   8.5cm² TO tweeter_Sd   IZrT1 TO tweeter_volume_velocity
.   0.25   TO distance_between_drivers
.   1      TO distance

!! frequency response /1m
*.include circuits/frequency_response_2way.fth

!! horizontal directivity
.include circuits/horizontal_directivity_2way.fth

!! vertical directivity
*. -10° TO vertical_angle
*.include circuits/vertical_directivity_2way.fth

! cone disp in mm
*.include circuits/cone_displacement_2way.fth

!phase
*.include circuits/phase_2way.fth

! phase delay in ms
*.include circuits/phase_delay_2way.fth

! ** group delay **
*. >>> F IZrT1 IZrW1 <<<     TO _woofer_volume_velocity
*.                           TO _tweeter_volume_velocity
*.                           TO _F
*.include circuits/group_delay_2way.fth

! total impedance
*. F .
*. v1 v0 - IEg / DUP ABS . ARG DEG .
