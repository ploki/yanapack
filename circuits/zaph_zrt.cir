* ZRT Zaph|Audio Revelator Tower *
* http://www.zaphaudio.com/ZRT.html *

.include circuits/driver.cir

* amp *
Eg 1 0 2.83

R8 1 2 6
C1 2 3 30u
L2 3 0 .25m .2
C4 3 4 10u
L6 4 5 1m 4.7
C5 5 0 80u

XD3004/6600 4 0 6 7 driver param: { .03m TO Le 3 TO Re 2.3 TO Bl \
	  	                    0.3 TO Rms 0.33m TO Cms 0.35m TO Mms \
			            7cm² TO Sd }
ZrT1 6 aGND 7cm² ai
ZrT2 7 aGND 7cm² ai

L10 1 9 2.7m .168
C12 9 0 12u
X18W/3531G00 9 0 10 11 driver param: { .35m TO Le 5.8 TO Re 6.8 TO Bl \
	  	                       0.6 TO Rms 1.85m TO Cms 17.5m TO Mms \
			               150cm² TO Sd }
ZrW1 10 aGND 150cm² ai
ZrW2 11 12 150cm² ai
Box 12 aGND 20L

* set logscale x
* set mxtics
* set mytics
* set style line 12 lc rgb '#ddccdd' lt 1 lw 1.5
* set style line 13 lc rgb '#ddccdd' lt 1 lw 0.5
* set grid xtics mxtics ytics mytics back ls 12, ls 13
* plot [16:40000] [40:100] 'plop.txt' using 1:2 title 'sum' with lines, 'plop.txt' using 1:3 title 'woofer' with lines, 'plop.txt' using 1:4 title 'tweeter' with lines

!general properties
. 150cm² TO woofer_Sd    IZrW1 TO woofer_volume_velocity
.   7cm² TO tweeter_Sd   IZrT1 TO tweeter_volume_velocity
.   0.25 TO distance_between_drivers
.   1    TO distance

!! frequency response /1m
.include circuits/frequency_response_2way.fth

!! horizontal directivity
*.include circuits/horizontal_directivity_2way.fth

!! vertical directivity
*. -10° TO vertical_angle
*.include circuits/vertical_directivity_2way.fth

! cone disp in mm
*.include circuits/cone_displacement_2way.fth

!phase
*.include circuits/phase_2way.fth

! phase delay in ms
*.include circuits/phase_delay_2way.fth

! ** group delay **
*. >>> F IZrT1 IZrW1 <<<     TO _woofer_volume_velocity
*.                           TO _tweeter_volume_velocity
*.                           TO _F
*.include circuits/group_delay_2way.fth

! total impedance
*. F .
*. v1 v0 - IEg / DUP ABS . ARG DEG .
